# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: Output +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\Origin_SDK\config;..\Origin_SDK\components;..\Origin_SDK\components\ble\ble_advertising;..\Origin_SDK\components\ble\ble_dtm;..\Origin_SDK\components\ble\ble_racp;..\Origin_SDK\components\ble\ble_services\ble_ancs_c;..\Origin_SDK\components\ble\ble_services\ble_ans_c;..\Origin_SDK\components\ble\ble_services\ble_bas;..\Origin_SDK\components\ble\ble_services\ble_bas_c;..\Origin_SDK\components\ble\ble_services\ble_cscs;..\Origin_SDK\components\ble\ble_services\ble_cts_c;..\Origin_SDK\components\ble\ble_services\ble_dfu;..\Origin_SDK\components\ble\ble_services\ble_dis;..\Origin_SDK\components\ble\ble_services\ble_gls;..\Origin_SDK\components\ble\ble_services\ble_hids;..\Origin_SDK\components\ble\ble_services\ble_hrs;..\Origin_SDK\components\ble\ble_services\ble_hrs_c;..\Origin_SDK\components\ble\ble_services\ble_hts;..\Origin_SDK\components\ble\ble_services\ble_ias;..\Origin_SDK\components\ble\ble_services\ble_ias_c;..\Origin_SDK\components\ble\ble_services\ble_lbs;..\Origin_SDK\components\ble\ble_services\ble_lbs_c;..\Origin_SDK\components\ble\ble_services\ble_lls;..\Origin_SDK\components\ble\ble_services\ble_nus;..\Origin_SDK\components\ble\ble_services\ble_nus_c;..\Origin_SDK\components\ble\ble_services\ble_rscs;..\Origin_SDK\components\ble\ble_services\ble_rscs_c;..\Origin_SDK\components\ble\ble_services\ble_tps;..\Origin_SDK\components\ble\common;..\Origin_SDK\components\ble\nrf_ble_gatt;..\Origin_SDK\components\ble\nrf_ble_qwr;..\Origin_SDK\components\ble\peer_manager;..\Origin_SDK\components\boards;..\Origin_SDK\components\drivers_nrf\usbd;..\Origin_SDK\components\libraries\atomic;..\Origin_SDK\components\libraries\atomic_fifo;..\Origin_SDK\components\libraries\atomic_flags;..\Origin_SDK\components\libraries\balloc;..\Origin_SDK\components\libraries\bootloader\ble_dfu;..\Origin_SDK\components\libraries\button;..\Origin_SDK\components\libraries\cli;..\Origin_SDK\components\libraries\crc16;..\Origin_SDK\components\libraries\crc32;..\Origin_SDK\components\libraries\crypto;..\Origin_SDK\components\libraries\csense;..\Origin_SDK\components\libraries\csense_drv;..\Origin_SDK\components\libraries\delay;..\Origin_SDK\components\libraries\ecc;..\Origin_SDK\components\libraries\experimental_section_vars;..\Origin_SDK\components\libraries\experimental_task_manager;..\Origin_SDK\components\libraries\fds;..\Origin_SDK\components\libraries\fstorage;..\Origin_SDK\components\libraries\gfx;..\Origin_SDK\components\libraries\gpiote;..\Origin_SDK\components\libraries\hardfault;..\Origin_SDK\components\libraries\hci;..\Origin_SDK\components\libraries\led_softblink;..\Origin_SDK\components\libraries\log;..\Origin_SDK\components\libraries\log\src;..\Origin_SDK\components\libraries\low_power_pwm;..\Origin_SDK\components\libraries\mem_manager;..\Origin_SDK\components\libraries\memobj;..\Origin_SDK\components\libraries\mpu;..\Origin_SDK\components\libraries\mutex;..\Origin_SDK\components\libraries\pwm;..\Origin_SDK\components\libraries\pwr_mgmt;..\Origin_SDK\components\libraries\queue;..\Origin_SDK\components\libraries\ringbuf;..\Origin_SDK\components\libraries\scheduler;..\Origin_SDK\components\libraries\sdcard;..\Origin_SDK\components\libraries\slip;..\Origin_SDK\components\libraries\sortlist;..\Origin_SDK\components\libraries\spi_mngr;..\Origin_SDK\components\libraries\stack_guard;..\Origin_SDK\components\libraries\strerror;..\Origin_SDK\components\libraries\svc;..\Origin_SDK\components\libraries\timer;..\Origin_SDK\components\libraries\twi_mngr;..\Origin_SDK\components\libraries\twi_sensor;..\Origin_SDK\components\libraries\usbd;..\Origin_SDK\components\libraries\usbd\class\audio;..\Origin_SDK\components\libraries\usbd\class\cdc;..\Origin_SDK\components\libraries\usbd\class\cdc\acm;..\Origin_SDK\components\libraries\usbd\class\hid;..\Origin_SDK\components\libraries\usbd\class\hid\generic;..\Origin_SDK\components\libraries\usbd\class\hid\kbd;..\Origin_SDK\components\libraries\usbd\class\hid\mouse;..\Origin_SDK\components\libraries\usbd\class\msc;..\Origin_SDK\components\libraries\util;..\Origin_SDK\components\nfc\ndef\conn_hand_parser;..\Origin_SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\Origin_SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\Origin_SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\Origin_SDK\components\nfc\ndef\connection_handover\ac_rec;..\Origin_SDK\components\nfc\ndef\connection_handover\ble_oob_advdata;..\Origin_SDK\components\nfc\ndef\connection_handover\ble_pair_lib;..\Origin_SDK\components\nfc\ndef\connection_handover\ble_pair_msg;..\Origin_SDK\components\nfc\ndef\connection_handover\common;..\Origin_SDK\components\nfc\ndef\connection_handover\ep_oob_rec;..\Origin_SDK\components\nfc\ndef\connection_handover\hs_rec;..\Origin_SDK\components\nfc\ndef\connection_handover\le_oob_rec;..\Origin_SDK\components\nfc\ndef\generic\message;..\Origin_SDK\components\nfc\ndef\generic\record;..\Origin_SDK\components\nfc\ndef\launchapp;..\Origin_SDK\components\nfc\ndef\parser\message;..\Origin_SDK\components\nfc\ndef\parser\record;..\Origin_SDK\components\nfc\ndef\text;..\Origin_SDK\components\nfc\ndef\uri;..\Origin_SDK\components\nfc\t2t_lib;..\Origin_SDK\components\nfc\t2t_lib\hal_t2t;..\Origin_SDK\components\nfc\t2t_parser;..\Origin_SDK\components\nfc\t4t_lib;..\Origin_SDK\components\nfc\t4t_lib\hal_t4t;..\Origin_SDK\components\nfc\t4t_parser\apdu;..\Origin_SDK\components\nfc\t4t_parser\cc_file;..\Origin_SDK\components\nfc\t4t_parser\hl_detection_procedure;..\Origin_SDK\components\nfc\t4t_parser\tlv;..\Origin_SDK\components\softdevice\common;..\Origin_SDK\components\softdevice\s132\headers;..\Origin_SDK\components\softdevice\s132\headers\nrf52;..\Origin_SDK\external\fprintf;..\Origin_SDK\external\segger_rtt;..\Origin_SDK\external\utf_converter;..\Origin_SDK\integration\nrfx;..\Origin_SDK\integration\nrfx\legacy;..\Origin_SDK\modules\nrfx;..\Origin_SDK\modules\nrfx\drivers\include;..\Origin_SDK\modules\nrfx\hal;..\Origin_SDK\modules\nrfx\mdk;.\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200022b8 size 0xdd48
  link misc: --diag_suppress 6330
  group Application
    src/: main.c
    config/: sdk_config.h
  group Board Definition
    ../Origin_SDK/components/boards/: boards.c
  group UTF8/UTF16 converter
    ../Origin_SDK/external/utf_converter/: utf.c
  group nRF_BLE
    ../Origin_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../Origin_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../Origin_SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../Origin_SDK/components/ble/ble_services/ble_lbs/: ble_lbs.c
  group nRF_Drivers
    ../Origin_SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../Origin_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c
    ../Origin_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../Origin_SDK/components/libraries/button/: app_button.c
    ../Origin_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../Origin_SDK/components/libraries/scheduler/: app_scheduler.c
    ../Origin_SDK/components/libraries/timer/: app_timer.c
    ../Origin_SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../Origin_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../Origin_SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../Origin_SDK/components/libraries/atomic/: nrf_atomic.c
    ../Origin_SDK/components/libraries/balloc/: nrf_balloc.c
    ../Origin_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../Origin_SDK/components/libraries/memobj/: nrf_memobj.c
    ../Origin_SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../Origin_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../Origin_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../Origin_SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../Origin_SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../Origin_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../Origin_SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_6.1.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s132_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200022b8 size 0xdd48
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
